# Keil uVision project powerTest.uvprojx, settings and files
target powerTest (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: powerTest +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c misc: --C99
  c include: ..\LIBRARY\CORE;..\LIBRARY\STM32F10x_FWLib\inc;..\USER\HARDWARE\INC;..\USER;..\USER\DEVICES\KEY;..\USER\DEVICES\LCD;..\USER\DEVICES\LED;..\USER\DEVICES\USB\CONFIG;..\USER\DEVICES\USB\STM32_USB-FS-Device_Driver\inc;..\USER\DEVICES\W25QXX
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ../USER/: main.c stm32f10x_it.c system_stm32f10x.c app.c
  group HARDWARE
    ../USER/HARDWARE/SRC/: adc.c dac.c delay.c dma.c sys.c timer.c usart.c spi.c
  group CORE
    ../LIBRARY/CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLib
    ../LIBRARY/STM32F10x_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_dma.c stm32f10x_dac.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_sdio.c stm32f10x_tim.c stm32f10x_spi.c stm32f10x_usart.c stm32f10x_wwdg.c stm32f10x_exti.c
  group DEVICES
    ../USER/DEVICES/KEY/: key.c
    ../USER/DEVICES/LCD/: lcd.c
    ../USER/DEVICES/LED/: led.c
    ../USER/DEVICES/W25QXX/: w25qxx.c
  group DOC
    ../DOC/: README.TXT
  group USB_CORE
    ../USER/DEVICES/USB/STM32_USB-FS-Device_Driver/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
  group USB_CONFIG
    ../USER/DEVICES/USB/CONFIG/: hw_config.c usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c
